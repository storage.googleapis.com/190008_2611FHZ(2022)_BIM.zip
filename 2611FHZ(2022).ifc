Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-19T15:27:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 19 15:27:41 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{76F61562-1892-493C-825E-12DF158D4BF7}\ifc * Database version: 5507 * Database creation date: Thu May 19 15:27:40 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 19 15:27:41 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 19 15:27:41 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 2611FHZ Washbasin faucet, 3 V, Bluetooth, 2611FHZ(2022):2611FHZ Washbasin faucet, 3 V, Bluetooth:306280
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm
Type - Electrical Engineering - Battery: AA 1.5 V Lithium x 2; Bluetooth: 5.x; Operating Voltage: 3 V; Protection Class: IP 55
Type - General - Author: BIMstone; BIMObjectName: 2611FHZ(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/05/2022
Type - Green Building Properties - Backflow Prevention EN1717: EB; EAN Number: 6414150099267; EMC Directive: 2014/53/EU , 2011/65/EU; EN Standard: EN 817, EN 15091; ETIM Class Number: EC011328 Washbasin mixing tap; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/2611FHZ; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/2611FHZ
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2611FHZ; Catalog Drawing URL: http://static.oras.com/catdrw/2611FHZ; Dimension Drawing URL: http://static.oras.com/dimdrw/2611FHZ; FDV Document URL: http://www.oras.com/datasheet/2611FHZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2611FHZ; Group: Washbasin faucet; Interactive AR View URL: https://static.oras.com/AR/2611FHZ; Item Type: Sales item; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2611FHZ; Model: 2611FHZ Washbasin faucet, 3 V, Bluetooth; Name_en: 2611FHZ Washbasin faucet, 3 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2611FHZ; Product Family: Oras Optima Style; Product Image URL: http://static.oras.com/image/2611FHZ; Product URL: http://static.oras.com/2611FHZ; Technical DataSheet URL: http://www.oras.com/datasheet/2611FHZ/en; Type Name: 2611FHZ Washbasin faucet, 3 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator;PCA® - constant flow rate regardless of pressure variations; Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: Infrared sensor;Solenoid valve;Low battery indicator; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Mounting Holes: 1 hole; Spout Projection: 147 mm; Spout Swivel Range: 120°; Spout Type: Swivel spout; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2611FHZ(2022); Features: Single-lever, side operated;Hybrid;Battery-operated;Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2611FHZ; Name: 2611FHZ Washbasin faucet, 3 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 55x175x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0867112 m2; Volume: 0.00433945 m3
Identity Data - Mark: 5
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2611FHZ(2022): 2611FHZ Washbasin faucet, 3 V, Bluetooth; Family and Type: 2611FHZ(2022): 2611FHZ Washbasin faucet, 3 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2611FHZ(2022): 2611FHZ Washbasin faucet, 3 V, Bluetooth; Type Id: 2611FHZ(2022): 2611FHZ Washbasin faucet, 3 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
